# Keil uVision project STM32F107.uvprojx, settings and files
target STM32F107 (6240000::V6.24::ARMCLANG)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM32F107 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Core/Inc;../Application/Inc;../Libraries/ADE7880/Inc;../Libraries/AM2315/Inc;../Libraries/DS18B20/Inc;../Libraries/DS18B20Manager/Inc;../Libraries/HIH/Inc;../Libraries/MovingAverage/Inc;../Libraries/OneWire/Inc;../Libraries/SensorAddressStore/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3f800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/Application
    ../Application/Src/: app.c diagnostic_led.c
  group Libraries/Reusable
    ../Libraries/ADE7880/Src/: ade7880.c
    ../Libraries/AM2315/Src/: am2315.c
    ../Libraries/DS18B20/Src/: ds18b20.c
    ../Libraries/DS18B20Manager/Src/: ds18b20_manager.c
    ../Libraries/HIH/Src/: hih.c
    ../Libraries/MovingAverage/Src/: moving_average.c
    ../Libraries/OneWire/Src/: one_wire.c
    ../Libraries/SensorAddressStore/Src/: sensor_address_store.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.6.0
